# Keil uVision project VerySimpleApplicationProcessor.uvprojx, settings and files
target VerySimpleApplicationProcessor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VerySimpleApplicationProcessor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: VerySimpleApplicationProcessor.c
    ../inc/: AP.c CortexM.c GPIO.c UART0.c UART1.c Clock.c LaunchPad.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
